# Keil uVision project cj3.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: cj3 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 多级通信从机2.c
